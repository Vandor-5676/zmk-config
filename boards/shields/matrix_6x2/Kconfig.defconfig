## boards/shields/matrix_6x2/Kconfig.defconfig
```kconfig
if SHIELD_MATRIX_6X2

config ZMK_KEYBOARD_NAME
    default "matrix-6x2"

endif # SHIELD_MATRIX_6X2
```
